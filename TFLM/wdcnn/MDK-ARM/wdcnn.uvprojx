# Keil uVision project wdcnn.uvprojx, settings and files
target wdcnn (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: wdcnn +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: TFLM_RUNTIME,CMSIS_NN,TFLM_RUNTIME_USE_ALL_OPERATORS=0,TF_LITE_STATIC_MEMORY,TF_LITE_DISABLE_X86_NEON,TF_LITE_MCU_DEBUG_LOG,ARM_MATH,ARM_MATH_LOOPUNROLL,ARM_MATH_DSP,ARM_MATH_CM4,__FPU_PRESENT=1U,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Middlewares/tensorflow/third_party/cmsis/CMSIS/DSP/Include/dsp;../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Include;../Middlewares/tensorflow/third_party/cmsis/CMSIS/DSP/Include;../Middlewares/tensorflow;../Middlewares/tensorflow/third_party/flatbuffers/include;../Middlewares/tensorflow/third_party/cmsis/CMSIS/Core/Include;../Middlewares/tensorflow/third_party/gemmlowp;../Middlewares/tensorflow/third_party/cmsis;../Middlewares/tensorflow/third_party/ruy;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: syscalls.c debug_log_imp.cc tflm_c.cc wdcnn.c main.c gpio.c crc.c app_x-cube-ai.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_1_x_n_s8.c arm_convolve_fast_s16.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SVDFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nntables.c arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group Middlewares/tensorflow/tensorflow/lite/micro
    ../Middlewares/tensorflow/tensorflow/lite/micro/: all_ops_resolver.cc fake_micro_context.cc flatbuffer_utils.cc memory_helpers.cc micro_allocation_info.cc micro_allocator.cc micro_context.cc micro_error_reporter.cc micro_graph.cc micro_interpreter.cc micro_profiler.cc micro_resource_variable.cc micro_string.cc micro_time.cc micro_utils.cc mock_micro_graph.cc recording_micro_allocator.cc system_setup.cc test_helpers.cc test_helper_custom_ops.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/kernels
    ../Middlewares/tensorflow/tensorflow/lite/micro/kernels/: activations.cc activations_common.cc add_common.cc add_n.cc arg_min_max.cc assign_variable.cc batch_to_space_nd.cc broadcast_args.cc broadcast_to.cc call_once.cc cast.cc ceil.cc circular_buffer.cc circular_buffer_common.cc comparisons.cc concatenation.cc conv_common.cc cumsum.cc depthwise_conv_common.cc depth_to_space.cc dequantize.cc dequantize_common.cc detection_postprocess.cc div.cc elementwise.cc elu.cc ethosu.cc exp.cc expand_dims.cc fill.cc floor.cc floor_div.cc floor_mod.cc fully_connected_common.cc gather.cc gather_nd.cc hard_swish.cc hard_swish_common.cc if.cc kernel_runner.cc kernel_util1.cc l2norm.cc l2_pool_2d.cc leaky_relu.cc leaky_relu_common.cc logical.cc logical_common.cc logistic.cc logistic_common.cc log_softmax.cc lstm_eval.cc maximum_minimum.cc micro_tensor_utils.cc mirror_pad.cc mul_common.cc neg.cc pack.cc pad.cc pooling_common.cc prelu.cc prelu_common.cc quantize.cc quantize_common.cc read_variable.cc reduce.cc reduce_common.cc reshape.cc resize_bilinear.cc resize_nearest_neighbor.cc round.cc select.cc shape.cc slice.cc softmax_common.cc space_to_batch_nd.cc space_to_depth.cc split.cc split_v.cc squared_difference.cc squeeze.cc strided_slice.cc sub.cc sub_common.cc svdf_common.cc tanh.cc transpose.cc transpose_conv.cc unidirectional_sequence_lstm.cc unpack.cc var_handle.cc while.cc zeros_like.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/kernels/cmsis_nn
    ../Middlewares/tensorflow/tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/arena_allocator
    ../Middlewares/tensorflow/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc recording_single_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/memory_planner
    ../Middlewares/tensorflow/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group Middlewares/tensorflow/tensorflow/lite/c
    ../Middlewares/tensorflow/tensorflow/lite/c/: common.cc
  group Middlewares/tensorflow/tensorflow/lite/kernels
    ../Middlewares/tensorflow/tensorflow/lite/kernels/: kernel_util.cc
  group Middlewares/tensorflow/tensorflow/lite/kernels/internal
    ../Middlewares/tensorflow/tensorflow/lite/kernels/internal/: quantization_util.cc
  group Middlewares/tensorflow/tensorflow/lite/kernels/internal/reference
    ../Middlewares/tensorflow/tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cc
  group Middlewares/tensorflow/tensorflow/lite/core/api
    ../Middlewares/tensorflow/tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group Middlewares/tensorflow/tensorflow/lite/schema
    ../Middlewares/tensorflow/tensorflow/lite/schema/: schema_utils.cc
software components: CMSIS:CORE 4.3.0
